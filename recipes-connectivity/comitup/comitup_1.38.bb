require comitup.inc

# v1.38
SRCREV = "0f5d16fdf350eac28e041a8426b2f66872da0bd3"

SRC_URI += " \
            git://github.com/davesteele/comitup;protocol=https;rev=${SRCREV} \
           "

