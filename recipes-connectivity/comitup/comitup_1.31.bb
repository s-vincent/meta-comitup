require comitup.inc

SRC_URI += " \
            git://github.com/davesteele/comitup;protocol=https;tag=main/${PV};nobranch=1 \
           "

